RS	0	1	4.00E+03
C1	1	2	1.00E-06
R3	2	0	8.00E+03
RE	5	0	3.30E+03
CE	5	0	1.00E-05
R2	2	3	4.00E+03
CB	3	0	1.00E-05
R1	3	0	1.80E+04
RC	6	0	6.00E+03
C2	6	7	1.00E-06
RL	7	0	4.00E+03
Q1	2	4	5 	hybridpix
Q2	3	6	4 	hybridpix
