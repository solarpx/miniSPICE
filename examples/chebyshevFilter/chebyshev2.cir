L1	1	2	91.34e-3
C1 	2	0	33.84e-9
L2 	2	3	169.2e-3
C2 	3	0	18.21e-9
