L1	1 	2	67.09e-3
C1	2	0	44.79e-9
L2	2	3	132.6e-3
C2	3	0	36.57e-9
L3	3	4	182.8e-3
C3	4	0	26.57e-9
L4	4	5	223.9e-3
C4	5	0	13.42e-9
