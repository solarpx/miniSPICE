Rgx 1 2 0.5
Cgs 2 4 21e-15
Cgd 2 3 130e-15
Cds 3 4 20e-15
Rds 3 4 228.653
Gm 3 4 2 4 0.080348
Rsx 4 5 2.5
Lsx 5 0 44e-12
Rdx 3 6 2.6
