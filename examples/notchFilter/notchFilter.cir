RS 1 2 50
RL 2 0 50
R 2 3 2.778
L 3 4 4.421e-7
C 4 0 1.423e-10
